# Keil uVision project K1921VK028Boot.uvproj, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: K1921VK028BootFlash
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c include: ..\K1921VK035
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
